# Keil uVision project n32g45_prj_template.uvprojx, settings and files
target N32G457VEL_STB_V1_1 (6240000::V6.24::ARMCLANG)
  device: N32G457VEL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.3.0
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: n32g45_prj_template
  c flags: Optim=8 OneElfS=1 uC99=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c include: .\Source\simple_delay;.\Source\led;.\Source\usart;.\Source\retarget;.\Driver\CMSIS\core;.\Driver\CMSIS\device;.\Driver\CMSIS\device\startup;.\Driver\n32g45x_std_periph_driver\inc;.\Source\coremark_1_0_1;.\Source\coremark_1_0_1\n32g45;.\Source
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  scatter file: .\scatter\n32g457.sct
  group App
    ./Source/: main.c n32g45x_it.c utils.c
    ./Source/coremark_1_0_1/: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c
    ./Source/coremark_1_0_1/n32g45/: core_portme.c
  group led
    ./Source/led/: led.c
  group simple_delay
    ./Source/simple_delay/: simple_delay.c
  group Document
    ./: README.md
  group usart
    ./Source/usart/: usart.c
  group retarget
    ./Source/retarget/: retarget_impl.c
  group FWLIB
    ./Driver/n32g45x_std_periph_driver/src/: misc.c n32g45x_dbg.c n32g45x_dma.c n32g45x_flash.c n32g45x_gpio.c n32g45x_rcc.c n32g45x_usart.c
  group STARTUP
    ./Driver/CMSIS/device/startup/: startup_n32g45x.s
  group CMSIS
    ./Driver/CMSIS/device/: system_n32g45x.c
  group scatter
    ./scatter/: n32g457.sct
  group doc
    ./: README.md
software components: CMSIS-Compiler:CORE 1.2.1, CMSIS-Compiler:STDOUT:Custom 1.1.0, CMSIS:CORE 6.2.0
